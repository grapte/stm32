# Keil uVision project timers.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: timers
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: three_timers.c pwm_25-50Hz.c touchscreen_216MHz.c
software components: CMSIS:CORE 5.1.1, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Graphic LCD 1.1.1, Board Support:Touchscreen 1.1.1, Device:STM32Cube Framework:Classic 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:I2C 1.2.6, Device:STM32Cube HAL:LTDC 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:SDRAM 1.2.6, Device:STM32Cube HAL:UART 1.2.6, Device:Startup 1.2.2
